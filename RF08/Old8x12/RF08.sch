# EAGLE board RF08 (EAGLE 4.11), part 2 of 2
## Tracks (layer width: path | path; a pad name or v marks a point on that pad's centre or on a via) (continued)
GND (continued)
  Top 0.254: C45.- 22.22,11.27 22.22,16.98 IC34.10 21.59,17.62 15.23,23.96 | 15.23,23.96 15.23,24.6 C35L.3 15.23,25.87 15.23,27.14 C35L.5 15.23,28.41 15.23,29.68 C35L.7 15.23,30.95 15.23,32.22 C35L.9 15.23,33.49 15.23,34.76 C35L.11 15.23,36.03 15.23,37.3 C35L.13 15.23,38.57 15.23,39.84 C35L.15 15.23,41.11 15.23,42.38 C35L.17 15.23,43.65 15.23,44.92 C35L.19 15.23,46.19 15.23,47.46 C35L.21 15.23,48.73 15.23,50 C35L.23 15.23,51.27 15.23,52.54 C35L.25 15.23,53.81 15.23,55.08 C35L.27 15.23,56.35 15.23,57.62 C35L.29 15.23,58.89 15.23,60.16 C35L.31 15.23,61.43 15.23,62.7 C35L.33 15.23,63.97 15.23,65.24 C35L.35 15.23,66.51 15.23,67.78 C35L.37 15.23,69.05 15.23,70.32 C35L.39 15.23,71.59 15.87,72.22 15.87,98.26 | 15.23,23.96 15.23,23.33 C35L.1 | IC16.15 101.59,117.94 99.06,115.4 99.06,112.86 IC16.1 99.69,110.96 99.69,106.52 100.33,105.88 100.33,99.53 99.06,98.26 C22.2 | C28.2 67.31,76.67 63.49,80.48 63.49,95.08 IC33.8 | IC13.1 18.41,110.96 19.68,110.96 IC13.2 | 15.87,98.26 12.06,102.07 12.06,106.52 C20.2 11.42,107.15 11.42,108.42 15.23,112.23 C13.2 | 15.87,98.26 17.14,96.99 IC20.17 | IC14.13 48.25,117.94 48.25,112.86 IC14.2 | C33.2 43.17,98.26 41.9,99.53 41.9,110.96 43.17,112.23 C14.2 | IC28.10 66.67,50 66.67,44.29 67.31,43.65 C35.2 67.31,42.38 71.75,37.94 71.75,30.95 | 67.31,17.62 72.39,22.7 IC35.13 73.02,23.33 71.75,24.6 71.75,25.87 | 67.31,17.62 IC35.10 67.31,17.62 | 67.31,17.62 67.31,16.98 75.56,8.73 C41.2 | 71.75,25.87 73.02,27.14 IC35.15 | 71.75,30.95 73.02,32.22 IC35.17 | 71.75,30.95 71.75,25.87 | D35L.39 86.36,70.32 86.36,69.05 D35L.37 86.36,67.78 86.36,66.51 D35L.35 86.36,65.24 86.36,63.97 D35L.33 86.36,62.7 86.36,61.43 D35L.31 86.36,60.16 86.36,58.89 D35L.29 86.36,57.62 86.36,56.35 D35L.27 86.36,55.08 86.36,53.81 D35L.25 86.36,52.54 86.36,51.27 D35L.23 86.36,50 86.36,48.73 D35L.21 86.36,47.46 86.36,46.19 D35L.19 86.36,44.92 86.36,43.65 D35L.17 86.36,42.38 86.36,41.11 D35L.15 86.36,39.84 86.36,38.57 D35L.13 86.36,37.3 86.36,36.03 D35L.11 86.36,34.76 86.36,33.49 D35L.9 86.36,32.22 86.36,30.95 D35L.7 86.36,29.68 86.36,28.41 D35L.5 86.36,27.14 86.36,25.87 D35L.3 86.36,24.6 86.36,23.33 D35L.1
  Top 0.254: C25.2 93.98,74.13 92.7,72.86 92.7,61.43 93.98,60.16 C29.2 | DMA0-3.4 133.98,16.98 132.71,15.71 132.71,9.36 133.98,8.09 DMA0-3.8 | 105.41,22.06 106.04,22.06 IC36.5 | 105.41,22.06 104.77,22.06 IC36.4 | D36L.1 127,23.33 127,24.6 D36L.3 127,25.87 127,27.14 D36L.5 | C46.2 135.25,27.78 127.63,27.78 D36L.5 | D36L.5 127,28.41 127,29.68 D36L.7 127,30.95 127,32.22 D36L.9 127,33.49 127,34.76 D36L.11 127,36.03 127,37.3 D36L.13 127,38.57 127,39.84 D36L.15 127,41.11 127,42.38 D36L.17 127,43.65 127,44.92 D36L.19 127,46.19 127,47.46 D36L.21 127,48.73 127,50 D36L.23 127,51.27 127,52.54 D36L.25 127,53.81 127,55.08 D36L.27 127,56.35 127,57.62 D36L.29 127,58.89 127,60.16 D36L.31 127,61.43 127,62.7 D36L.33 127,63.97 127,65.24 D36L.35 127,66.51 127,67.78 D36L.37 127,69.05 127,70.32 D36L.39 | 105.41,22.06 105.41,12.54 109.22,8.73 IC23.2 | IC24.10 165.73,75.4 166.37,74.77 166.37,67.78 C31.2 | DAR8-11.4 149.22,85.56 147.95,84.29 147.95,77.94 149.22,76.67 DAR8-11.8 150.49,75.4 151.12,74.77 151.12,62.7 C42.2 150.49,62.06 147.95,62.06 147.95,50 | IC31.10 165.73,41.11 166.37,40.48 166.37,33.49 C38.2 | C40.2 151.12,25.87 151.12,40.48 150.49,41.11 DAR4-7.8 149.22,42.38 147.95,43.65 147.95,50 | 147.95,50 149.22,51.27 DAR4-7.4 | 132.71,84.29 132.71,77.94 133.98,76.67 DMA8-11.8 134.62,75.4 134.62,69.05 135.25,68.41 135.25,62.06 C39.2 | 132.71,84.29 133.98,85.56 DMA8-11.4 | 132.71,84.29 132.71,96.35 135.25,96.35 C8.2 | IC22.7 116.84,97.62 118.11,98.89 118.11,109.05 116.84,110.32 IC16.8 | IC17.1 129.53,112.86 132.08,115.4 132.08,117.94 IC17.15 132.08,120.48 132.08,123.02 IC9.2 132.08,125.56 132.08,126.2 133.34,127.47 133.34,129.38 134.62,130.65 IC9.12 133.98,132.55 132.08,134.46 127,134.46 127,137.63 C5.2
  Top 0.254: IC1.7 28.57,136.36 29.84,136.36 IC1.8 | IC7.15 185.41,130.65 182.88,128.11 182.88,125.56 IC7.1 | IC6.8 174.62,136.36 171.44,133.19 171.44,129.38 172.72,128.11 172.72,125.56 IC10.7 | IC10.12 162.56,130.65 160.02,128.11 160.02,125.56 IC10.2 | IC5.7 144.78,135.72 146.05,134.46 146.05,126.83 144.78,125.56 IC9.7 144.78,123.02 146.05,121.75 146.05,116.67 147.31,115.4 147.31,112.86 IC17.8 | C44X.2 212.09,133.82 211.45,133.19 211.45,132.55 IC8.1 209.55,131.92 208.28,131.92 201.29,124.93 IC7.8 200.02,123.66 196.84,120.48 196.84,116.67 200.66,112.86 IC11.7 | IC12.7 211.45,95.72 212.09,95.08 212.09,91.91 C44.2 | C24.2 166.37,102.07 172.72,108.42 172.72,110.32 IC18.7 | IC12.7 211.45,96.99 212.72,98.26 212.72,114.13 C12.2 | 205.74,12.54 205.74,16.35 INTENB.9 | 205.74,12.54 205.74,11.27 INTENB.8 | IC37.10 210.18,8.09 208.91,9.36 208.91,15.71 210.18,16.98 IC37.6 | INTENB.4 196.21,9.36 197.48,9.36 INTENB.5 198.12,11.27 198.12,12.54 205.74,12.54 | 170.81,7.46 171.44,7.46 IC38.11 | 170.81,7.46 166.37,7.46 IC38.10 | 170.81,10.63 172.08,11.9 IC38.13 | 170.81,10.63 170.81,7.46 | 170.81,15.71 172.08,16.98 IC38.15 | 170.81,10.63 170.81,15.71 | 170.81,15.71 170.81,20.79 172.08,22.06 IC38.17 | J14.2 193.03,23.33 193.03,24.6 J13.2 193.03,25.87 193.03,27.14 J12.2 193.03,28.41 193.03,29.68 J11.2 193.03,30.95 193.03,32.22 J10.2 193.03,33.49 193.03,34.76 J9.2 193.03,36.03 193.03,37.3 J8.2 | D34L.39 185.41,70.32 185.41,69.05 D34L.37 185.41,67.78 185.41,66.51 D34L.35 185.41,65.24 185.41,63.97 D34L.33 185.41,62.7 185.41,61.43 D34L.31 185.41,60.16 185.41,58.89 D34L.29 185.41,57.62 185.41,56.35 D34L.27 185.41,55.08 185.41,53.81 D34L.25 185.41,52.54 185.41,51.27 D34L.23 185.41,50 185.41,48.73 D34L.21 185.41,47.46 185.41,46.19 D34L.19 185.41,44.92 185.41,43.65 D34L.17 185.41,42.38 185.41,41.11 D34L.15 185.41,39.84 185.41,38.57 D34L.13 185.41,37.3 185.41,36.03 D34L.11 185.41,34.76 185.41,33.49 D34L.9 185.41,32.22 185.41,30.95 D34L.7 185.41,29.68 185.41,28.41 D34L.5 185.41,27.14 185.41,25.87 D34L.3 185.41,24.6 185.41,23.33 D34L.1 185.41,22.06 185.41,18.25 184.15,16.98 184.15,13.17 185.41,11.9 C43.2
  Top 0.254: FIELD.4 210.18,80.48 210.18,79.21 FIELD.5 210.18,77.94 208.91,76.67 | C30.2 212.09,63.97 211.45,64.6 211.45,70.32 FIELD.8 210.18,71.59 208.91,72.86 208.91,76.67 | C36L.1 203.19,23.33 203.19,24.6 C36L.3 203.19,25.87 203.19,27.14 C36L.5 203.19,28.41 203.19,29.68 C36L.7 203.19,30.95 203.19,32.22 C36L.9 203.19,33.49 203.19,34.76 C36L.11 203.19,36.03 203.19,37.3 C36L.13 203.19,38.57 203.19,39.84 C36L.15 203.19,41.11 203.19,42.38 C36L.17 203.19,43.65 203.19,44.92 C36L.19 203.19,46.19 203.19,47.46 C36L.21 203.19,48.73 203.19,50 C36L.23 203.19,51.27 203.19,52.54 C36L.25 203.19,53.81 203.19,55.08 C36L.27 203.19,56.35 203.19,57.62 C36L.29 203.19,58.89 203.19,60.16 C36L.31 203.19,61.43 203.19,62.7 C36L.33 203.19,63.97 203.19,65.24 C36L.35 203.19,66.51 203.19,67.78 C36L.37 203.19,69.05 203.19,70.32 C36L.39 | 208.91,76.67 208.91,94.45 210.18,95.72 IC12.7
  Bottom 0.254: RS08.39 37.46,22.7 36.19,23.96 17.14,23.96 15.87,25.23 C35L.3 | C35L.17 15.87,43.02 23.49,43.02 C34.2 24.76,43.02 28.57,39.2 32.38,39.2 38.09,33.49 RS08.31 | 10.79,74.77 10.79,72.22 13.33,72.22 14.6,70.95 C35L.39 | 10.79,74.77 10.79,80.48 IC20.10 | 10.79,74.77 22.22,74.77 23.49,76.03 C26.2 | IC26.10 21.59,50.63 15.87,50.63 C35L.23 | J2.2 10.79,50.63 12.06,51.91 13.33,51.91 14.6,53.18 C35L.25 | IC21.8 92.07,96.99 92.7,97.62 98.42,97.62 C22.2 | C21.2 70.48,97.62 64.77,97.62 64.13,96.99 IC33.8 62.86,96.99 61.59,98.26 43.17,98.26 C33.2 | C13.2 15.87,112.86 16.51,112.23 17.14,112.23 IC13.1 | IC14.2 47.62,110.96 46.35,110.96 IC14.1 45.71,112.86 45.71,113.5 | 51.43,113.5 52.7,112.23 IC14.4 | 45.71,113.5 43.17,113.5 C14.2 42.54,112.86 34.28,112.86 33.65,112.23 IC13.7 32.38,110.96 31.11,109.69 22.22,109.69 20.95,110.96 IC13.2 | 51.43,113.5 45.71,113.5 | 51.43,113.5 59.05,113.5 60.32,112.23 IC14.7 61.59,112.23 62.22,112.86 70.48,112.86 C15.2 71.12,113.5 79.37,113.5 80.64,112.23 IC15.4 81.91,110.96 83.18,109.69 86.99,109.69 88.26,110.96 IC15.7 89.53,112.23 90.17,112.86 95.88,112.86 C16.2 97.15,112.86 97.79,112.86 98.42,112.23 IC16.1 99.69,110.96 100.96,109.69 114.93,109.69 116.2,110.96 IC16.8 117.47,110.96 128.9,110.96 IC17.1 128.9,112.23 128.27,112.23 127.63,112.86 C17.2 | 104.77,75.4 106.04,74.13 IC25.5 | 104.77,75.4 93.98,75.4 C25.2 | 104.77,75.4 112.39,75.4 113.66,74.13 IC25.8 | D35L.29 86.99,58.26 88.26,59.52 93.34,59.52 C29.2 93.98,60.16 104.77,60.16 106.04,58.89 IC29.5 107.31,57.62 108.58,56.35 112.39,56.35 113.66,57.62 IC29.8 | D35L.3 86.99,25.23 92.07,25.23 93.34,23.96 C36.2 93.98,23.33 93.98,20.79 108.58,20.79
  Bottom 0.254: D35L.19 86.99,45.55 92.07,45.55 93.34,44.29 C32.2 93.98,44.92 104.77,44.92 | 104.77,44.92 106.04,43.65 IC32.5 | 104.77,44.92 112.39,44.92 113.66,43.65 IC32.8 | IC35.17 74.93,32.86 76.2,31.59 84.45,31.59 85.72,30.32 D35L.7 | IC41.8 97.15,8.09 97.79,8.73 103.5,8.73 C23.2 104.14,9.36 107.31,9.36 | 107.31,9.36 108.58,8.09 IC23.2 | 108.58,20.79 112.39,20.79 113.66,22.06 IC36.8 114.93,22.06 115.56,21.43 125.09,21.43 126.36,22.7 D36L.1 | 108.58,20.79 107.31,22.06 IC36.5 | 107.31,9.36 120.01,9.36 121.28,8.09 IC23.7 122.55,7.46 133.34,7.46 DMA0-3.8 135.88,7.46 137.16,8.73 147.31,8.73 148.59,7.46 IC40.7 151.12,7.46 152.4,8.73 158.75,8.73 160.02,7.46 163.83,7.46 IC38.10 | C31.2 165.73,67.14 164.46,65.88 161.92,65.88 160.02,63.97 153.66,63.97 151.76,62.06 C42.2 | IC31.10 163.83,41.74 160.02,41.74 158.75,43.02 153.03,43.02 151.76,41.74 151.12,41.74 DAR4-7.8 | C27.2 150.49,96.35 149.22,97.62 137.79,97.62 136.52,96.35 C8.2 | C39.2 135.25,62.06 133.98,60.8 127.63,60.8 D36L.31 | DMA4-7.8 133.34,41.74 132.08,43.02 127.63,43.02 D36L.17 | DMA4-7.4 133.34,51.91 132.71,51.27 127,51.27 D36L.23 | DAR8-11.8 148.59,76.03 147.31,77.3 139.69,77.3 138.43,76.03 135.88,76.03 DMA8-11.8 | C9.2 127.63,125.56 128.27,126.2 130.17,126.2 131.44,124.93 IC9.2 132.71,123.66 133.98,122.39 142.87,122.39 144.14,123.66 IC9.7 145.41,124.93 146.05,125.56 154.3,125.56 C10.2 154.94,126.2 158.11,126.2 159.38,124.93 IC10.2 160.65,123.66 161.92,122.39 170.81,122.39 172.08,123.66 IC10.7 173.35,124.93 173.99,125.56 179.7,125.56 C7.2 180.97,125.56 181.61,125.56 182.24,124.93 IC7.1
  Bottom 0.254: C5.2 126.36,138.27 125.73,137.63 114.93,137.63 IC4.8 113.66,136.36 112.39,136.36 IC4.7 111.12,137.63 109.85,138.9 93.98,138.9 C4.2 93.34,138.27 92.7,137.63 86.99,137.63 IC3.8 85.72,136.36 84.45,136.36 IC3.7 83.18,137.63 81.91,138.9 66.04,138.9 C3.2 65.4,138.27 64.77,137.63 59.05,137.63 IC2.8 57.78,136.36 56.51,136.36 IC2.7 55.24,137.63 53.97,138.9 38.09,138.9 C2.2 37.46,138.27 36.82,137.63 31.11,137.63 IC1.8 | C1.2 10.79,138.27 11.42,138.9 26.03,138.9 27.3,137.63 IC1.7 | IC5.7 145.41,137.63 146.05,138.27 154.3,138.27 C6.2 | IC19.7 201.29,89.37 203.19,91.27 211.45,91.27 C44.2 | C12.2 211.45,114.13 203.19,114.13 201.29,112.23 IC11.7 200.02,112.23 198.75,113.5 182.88,113.5 C11.2 182.24,112.86 181.61,112.23 173.35,112.23 IC18.7 172.08,112.23 170.81,113.5 156.21,113.5 155.57,112.86 C18.2 154.3,112.86 148.59,112.86 147.95,112.23 IC17.8 | C19.2 189.86,98.89 188.59,100.16 168.91,100.16 167.63,101.43 167,101.43 C24.2 | INTENB.9 206.37,17.62 209.55,17.62 IC37.6 | IC38.13 173.99,12.54 183.51,12.54 184.78,11.27 C43.2 185.41,11.9 193.67,11.9 194.94,10.63 INTENB.4 | J6.2 192.4,43.02 186.05,43.02 D34L.17 | J8.2 192.4,37.94 186.05,37.94 D34L.13 | FIELD.9 217.16,70.95 212.09,70.95 FIELD.8 209.55,70.95 203.83,70.95 C36L.39 | C37.2 211.45,32.86 203.83,32.86 C36L.9 | IC30.10 209.55,37.94 203.83,37.94 C36L.13 | IC30.6 209.55,48.09 203.83,48.09 C36L.21 | J9.2 193.67,35.4 194.94,34.12 201.29,34.12 202.56,35.4 C36L.11
  pour Bottom: -0.01,152.24 228.59,152.24 228.59,-0.17 -0.01,-0.17
  pour Top: -0.01,152.24 228.59,152.24 228.59,-0.17 -0.01,-0.17
INT_RQ\  (via drill 0.61)
  Top 0.254: 147.95,11.9 149.22,10.63 IC40.6 | 147.95,11.9 147.95,15.71 149.22,16.98 IC40.3 | 147.95,11.9 147.95,4.28 153.03,4.28 156.21,7.46 IC40.8 | v175.25,7.46 175.25,9.36 184.15,18.25 184.15,51.91 182.24,51.91 181.61,52.54 181.61,56.35 182.88,57.62 D34L.30
  Bottom 0.254: v175.25,7.46 173.99,6.18 160.02,6.18 158.75,7.46 IC40.8
IOS\  (via drill 0.61)
  Top 0.254: v107.95,121.12 112.39,121.12 113.03,120.48 113.03,106.52 111.76,105.24 IC22.10 | v179.06,121.75 178.43,121.12 178.43,86.83 179.7,85.56 v179.7,58.26
  Bottom 0.254: v107.95,121.12 108.58,121.75 v179.06,121.75 | v179.7,58.26 182.24,55.72 D34L.28
MYDEV\
  Top 0.254: IC25.4 104.14,72.22 102.87,70.95 102.87,60.8 104.14,59.52 IC29.4 104.14,56.98 102.87,55.72 102.87,47.46 104.14,46.19 104.14,44.29 IC32.4 104.77,42.38 111.76,35.4 113.66,35.4 PAD1.1
N$1
  Top 0.254: IC36.9 114.3,31.59 114.3,32.22 PAD8.1
N$2
  Top 0.254: IC10.8 173.35,132.55 176.53,135.72 176.53,147.79 177.8,149.06 196.84,149.06 196.84,123.02 193.67,119.85 IC11.11
N$3  (via drill 0.61)
  Top 0.254: v144.78,13.81 145.41,14.44 v145.41,47.46
  Bottom 0.254: v144.78,13.81 137.16,13.81 135.88,15.08 DMA0-3.5 | v145.41,47.46 143.5,49.37 DMA4-7.12
N$4
  Top 0.254: SW1.1 13.33,123.66 14.6,123.66 SW1.2 15.87,123.66 17.14,123.66 SW1.3 18.41,123.66 19.68,123.66 SW1.4 20.95,123.66 22.22,123.66 SW1.5 23.49,123.66 24.76,123.66 SW1.6 26.03,123.66 27.3,123.66 SW1.7 28.57,123.66 29.84,123.66 SW1.8
  Bottom 0.254: IC33.4 52.7,95.72 51.43,94.45 24.76,94.45 19.05,100.16 16.51,100.16 13.33,103.34 13.33,123.02 12.69,123.02 SW1.1
N$5
  Top 0.254: IC36.15 99.06,31.59 99.06,32.22 PAD2.1
N$6
  Top 0.254: IC36.14 101.59,31.59 101.59,32.22 PAD3.1
N$7
  Top 0.254: IC36.13 104.14,31.59 104.14,32.22 PAD4.1
N$8
  Top 0.254: IC36.12 106.68,31.59 106.68,32.22 PAD5.1
N$9
  Top 0.254: IC36.11 109.22,31.59 109.22,32.22 PAD6.1
N$10
  Top 0.254: IC36.10 111.76,31.59 111.76,32.22 PAD7.1
N$11
  Top 0.254: IC36.7 111.76,23.96 116.84,29.05 116.84,32.22 PAD9.1
N$12
  Top 0.254: DAR4-7.14 156.84,55.08 155.57,56.35 155.57,60.16 156.21,60.8 157.47,60.8 157.47,73.49 155.57,75.4 155.57,86.83 156.84,88.1 DAR8-11.14 158.11,89.37 159.38,90.64 159.38,94.45 158.75,95.08 158.75,98.89 168.91,109.05 168.91,114.13 172.72,117.94 IC18.8
N$13  (via drill 0.61)
  Top 0.254: v145.41,53.18 144.78,53.81 144.78,81.11 142.87,83.02 DMA8-11.12
  Bottom 0.254: v145.41,53.18 139.69,53.18 135.88,49.37 DMA4-7.5
N$14  (via drill 0.61)
  Top 0.254: v33.65,114.77 33.65,117.31 33.02,117.94 IC13.8
  Bottom 0.254: v33.65,114.77 34.28,114.13 55.88,114.13 57.14,115.4 | 57.14,115.4 60.32,118.58 IC14.8 | 57.14,115.4 82.55,115.4 85.72,112.23 IC15.6
N$15
  Top 0.254: IC2.5 50.79,135.72 52.06,134.46 52.06,130.65 54.6,128.11 92.07,128.11 92.07,143.34 99.06,150.33 130.81,150.33 130.81,139.53 132.08,138.27 IC5.2
N$16  (via drill 0.61)
  Top 0.254: v146.05,71.59 145.41,70.95 145.41,54.45 146.68,53.18 146.68,11.27 140.97,11.27 140.33,11.9 140.33,13.17 141.6,14.44 DMA0-3.12 | v140.33,73.49 139.06,74.77 v139.06,80.48
  Bottom 0.254: v146.05,71.59 144.14,73.49 v140.33,73.49 | v139.06,80.48 140.97,82.38 147.31,82.38 148.59,83.65 DAR8-11.5
N$17
  Top 0.254: SW2.1 41.27,123.66 42.54,123.66 SW2.2 43.81,123.66 45.08,123.66 SW2.3 46.35,123.66 47.62,123.66 SW2.4 48.89,123.66 50.16,123.66 SW2.5 51.43,123.66 52.7,123.66 SW2.6 53.34,123.02 53.34,122.39 54.6,121.12 54.6,98.89 55.88,97.62 IC33.5 | SW2.8 57.78,123.66 56.51,123.66 SW2.7
  Bottom 0.254: SW2.7 55.24,123.66 53.97,123.66 SW2.6
N$19  (via drill 0.61)
  Top 0.254: v67.94,94.45 67.94,123.66 SW3.1 69.21,123.66 70.48,123.66 SW3.2 71.75,123.66 73.02,123.66 SW3.3 74.29,123.66 75.56,123.66 SW3.4 76.83,123.66 78.1,123.66 SW3.5 79.37,123.66 80.64,123.66 SW3.6 81.91,123.66 83.18,123.66 SW3.7 84.45,123.66 85.72,123.66 SW3.8
  Bottom 0.254: v67.94,94.45 60.32,94.45 59.05,95.72 IC33.6
N$20  (via drill 0.61)
  Top 0.254: v62.22,122.39 62.22,98.89 60.95,97.62 IC33.7 | SW4.1 97.15,123.66 98.42,123.66 SW4.2 99.69,123.66 100.96,123.66 SW4.3 102.23,123.66 103.5,123.66 SW4.4 104.77,123.66 106.04,123.66 SW4.5 107.31,123.66 108.58,123.66 SW4.6 109.85,123.66 111.12,123.66 SW4.7
  Bottom 0.254: v62.22,122.39 94.61,122.39 95.88,123.66 SW4.1 | SW4.8 113.66,123.66 112.39,123.66 SW4.7
N$21  (via drill 0.61)
  Top 0.254: v77.47,148.43 77.47,143.34 78.1,142.71 78.1,138.9 78.73,138.27 IC3.5 | v133.98,147.79 135.88,145.89 135.88,139.53 137.16,138.27 IC5.4
  Bottom 0.254: v77.47,148.43 78.1,147.79 v133.98,147.79
N$22  (via drill 0.61)
  Top 0.254: 140.33,52.54 140.33,41.11 142.24,39.2 142.24,26.51 140.97,26.51 140.33,25.87 140.33,22.06 141.6,20.79 DMA0-3.14 | 140.33,52.54 141.6,53.81 DMA4-7.14 | 140.33,52.54 140.33,60.8 141.6,60.8 142.24,61.43 142.24,72.86 140.33,74.77 140.33,86.83 141.6,88.1 DMA8-11.14 142.87,89.37 144.14,90.64 144.14,103.97 v146.05,105.88 | v169.54,108.42 169.54,109.69 170.18,110.32 IC18.6
  Bottom 0.254: v169.54,108.42 167,105.88 v146.05,105.88
N$23
  Bottom 0.254: IC1.5 23.49,136.36 24.76,135.09 127.63,135.09 128.9,136.36 IC5.1
N$24  (via drill 0.61)
  Top 0.254: v104.77,140.17 106.68,138.27 IC4.5
  Bottom 0.254: v104.77,140.17 105.41,139.53 137.16,139.53 139.06,137.63 IC5.5
N$25  (via drill 0.61)
  Top 0.254: v153.66,49.37 153.03,50 153.03,70.32 153.66,70.95 153.66,71.59 153.03,72.22 153.03,80.48 153.66,81.11 153.66,83.02 v153.03,83.65
  Bottom 0.254: v153.66,49.37 151.12,49.37 DAR4-7.5 | v153.03,83.65 156.21,83.65 DAR8-11.12
N$26
  Top 0.254: IC22.1 101.59,97.62 102.87,98.89 102.87,112.86 107.31,117.31 111.12,117.31 111.12,118.58 IC16.11
N$27  (via drill 0.61)
  Top 0.254: v135.88,107.15 137.16,108.42 137.16,110.32 IC17.4
  Bottom 0.254: v135.88,107.15 112.39,107.15 109.85,104.61 IC22.11
N$28
  Top 0.254: IC19.1 185.41,90 180.34,95.08 180.34,123.66 179.06,124.93 179.06,131.28 181.61,133.82 189.22,133.82 189.22,130.65 189.86,130.01 191.77,130.01 191.77,133.19 192.4,133.82 194.31,133.82 194.31,126.83 193.03,125.56 IC7.5
N$29
  Top 0.254: RA.2 220.97,119.85 220.97,121.12 RB.1 220.97,122.39 222.25,123.66 222.25,125.56 219.07,128.74 IC8.7
N$30
  Top 0.254: IC12.2 210.18,109.69 210.18,110.96 IC12.1 210.18,112.23 209.55,112.86 209.55,121.12 208.28,122.39 208.28,128.74 RL.2
  Bottom 0.254: IC8.3 210.18,127.47 208.91,128.74 208.28,128.74 RL.2
N$31
  Top 0.254: IC18.11 165.09,120.48 166.37,121.75 166.37,129.38 167.63,130.65 IC10.10
N$32
  Top 0.254: RB.2 210.18,121.75 208.91,123.02 208.91,127.47 210.18,128.74 IC8.2
  Bottom 0.254: 212.72,129.38 212.09,129.38 IC8.2 | 212.72,129.38 214.62,129.38 217.16,126.83 IC8.6 | 212.72,129.38 217.16,133.82 C44X.1
N$33
  Top 0.254: IC19.11 193.03,97.62 191.77,98.89 191.77,128.74 193.03,130.01 193.03,130.65 IC7.12
N$34
  Top 0.254: IC8.5 219.71,124.29 220.34,124.29 C43X.2
N$37
  Top 0.254: IC12.9 217.8,99.53 217.8,100.8 IC12.10 217.8,102.07 217.8,103.34 IC12.11
N$40
  Bottom 0.254: IC12.5 212.09,101.43 217.16,96.35 IC12.8
N$53
  Bottom 0.254: SW1.16 13.33,131.28 14.6,130.01 18.41,130.01 19.05,130.65 19.05,136.36 19.68,136.36 IC1.4
N$54
  Top 0.254: SW1.15 15.23,133.19 17.78,135.72 IC1.3
N$55
  Bottom 0.254: SW1.14 17.78,133.19 15.23,135.72 IC1.2
N$56
  Top 0.254: IC1.1 12.69,135.72 13.96,134.46 13.96,130.65 14.6,130.01 19.68,130.01 19.68,131.28 SW1.13
N$57
  Bottom 0.254: SW1.11 24.76,131.28 22.86,129.38 12.69,129.38 8.88,133.19 8.88,142.08 15.23,142.08 17.14,143.98 IC1.14
N$58
  Top 0.254: SW1.10 27.94,133.19 26.67,134.46 26.67,140.81 24.12,143.34 24.12,145.89 23.49,146.52 20.32,146.52 20.32,145.89 IC1.13
N$59
  Top 0.254: SW1.9 29.84,131.28 28.57,130.01 24.12,130.01 24.12,142.08 22.86,143.34 IC1.12
N$60
  Top 0.254: SW1.12 22.22,132.55 19.05,135.72 19.05,139.53 15.23,143.34 IC1.15
N$61
  Top 0.254: SW2.16 40.63,133.19 41.9,134.46 41.9,138.9 42.54,139.53 48.25,139.53 48.25,138.27 IC2.4
N$62
  Top 0.254: SW2.15 43.17,133.19 45.71,135.72 IC2.3
N$63
  Top 0.254: SW2.14 45.71,133.19 46.98,134.46 46.98,138.27 46.35,138.9 43.17,138.9 43.17,138.27 IC2.2
N$64
  Top 0.254: IC2.1 40.63,135.72 39.36,134.46 39.36,130.65 40,130.01 47.62,130.01 47.62,131.28 SW2.13
N$65
  Top 0.254: SW2.11 53.97,131.28 55.24,130.01 59.68,130.01 59.68,133.19 57.14,135.72 57.14,138.27 52.06,143.34 52.06,145.89 51.43,146.52 45.71,146.52 45.71,145.89 IC2.14
N$66
  Top 0.254: SW2.10 55.24,132.55 52.06,135.72 52.06,139.53 48.25,143.34 IC2.13
N$67
  Top 0.254: SW2.9 57.78,132.55 54.6,135.72 54.6,139.53 50.79,143.34 IC2.12
N$68
  Top 0.254: SW3.16 69.21,131.28 70.48,130.01 74.93,130.01 74.93,133.19 76.2,134.46 76.2,135.72 IC3.4
N$69
  Top 0.254: SW3.15 71.12,133.19 73.66,135.72 IC3.3
N$70
  Top 0.254: SW3.14 73.66,133.19 74.93,134.46 74.93,138.27 74.29,138.9 71.12,138.9 71.12,138.27 IC3.2
N$71
  Top 0.254: IC3.1 68.58,135.72 67.31,134.46 67.31,130.65 68.58,129.38 75.56,129.38 75.56,131.28 SW3.13
N$72
  Top 0.254: SW3.11 81.28,133.19 82.55,134.46 82.55,145.89 78.1,150.33 69.84,150.33 69.84,143.34 70.48,142.71 73.02,142.71 73.02,143.98 IC3.14
N$73
  Top 0.254: SW3.10 83.18,131.28 81.91,130.01 77.47,130.01 77.47,142.08 76.2,143.34 IC3.13
N$74  (via drill 0.61)
  Top 0.254: v85.09,138.9 85.09,134.46 86.36,133.19 SW3.9 | v79.37,141.44 78.73,142.08 78.73,143.34 IC3.12
  Bottom 0.254: v85.09,138.9 82.55,141.44 v79.37,141.44
N$75
  Top 0.254: SW4.16 96.52,133.19 97.79,134.46 97.79,138.9 98.42,139.53 104.14,139.53 104.14,138.27 IC4.4
N$76
  Top 0.254: SW4.15 99.06,133.19 101.59,135.72 IC4.3
N$77
  Top 0.254: SW4.14 101.59,133.19 102.87,134.46 102.87,138.27 102.23,138.9 99.06,138.9 99.06,138.27 IC4.2
N$78
  Top 0.254: IC4.1 96.52,135.72 95.25,134.46 95.25,130.65 95.88,130.01 103.5,130.01 103.5,131.28 SW4.13
N$79
  Top 0.254: SW4.11 109.22,133.19 107.95,134.46 107.95,138.27 102.23,143.98 IC4.14
N$80
  Top 0.254: SW4.10 112.39,131.28 113.66,130.01 115.56,130.01 115.56,133.19 113.03,135.72 113.03,138.27 107.95,143.34 107.95,145.89 107.31,146.52 104.14,146.52 104.14,145.89 IC4.13
N$81
  Top 0.254: SW4.9 113.66,132.55 110.48,135.72 110.48,139.53 106.68,143.34 IC4.12
N$82
  Top 0.254: SW4.12 106.04,131.28 104.14,129.38 94.61,129.38 94.61,137 95.25,137.63 95.25,139.53 99.06,143.34 IC4.15
N$83
  Top 0.254: SW3.12 78.73,133.19 80.01,134.46 80.01,140.81 80.64,141.44 80.64,142.71 80.01,143.34 80.01,147.16 77.47,149.7 71.12,149.7 71.12,145.89 IC3.15
N$84
  Top 0.254: SW2.12 50.79,133.19 49.52,134.46 49.52,139.53 46.35,142.71 43.17,142.71 43.17,143.34 IC2.15
NXD  (via drill 0.61)
  Top 0.254: v121.28,3.01 117.47,6.82 IC23.5 | v209.55,3.01 208.28,4.28 208.28,32.86 212.72,37.3 212.72,51.27 211.45,52.54 IC30.4
  Bottom 0.254: v121.28,3.01 122.55,1.74 208.28,1.74 v209.55,3.01
NXD\  (via drill 0.61)
  Top 0.254: v120.65,4.92 119.38,6.18 IC23.6 | v216.53,6.18 222.25,6.18 222.25,102.7 219.07,105.88 IC12.12
  Bottom 0.254: v120.65,4.92 135.88,4.92 136.52,5.55 150.49,5.55 151.76,6.82 155.57,6.82 156.84,5.55 188.59,5.55 189.22,6.18 196.84,6.18 197.48,5.55 215.9,5.55 v216.53,6.18
PBIT  (via drill 0.61)
  Top 0.254: v71.12,20.16 73.02,18.25 IC35.11 | v62.22,21.43 60.95,22.7 60.95,93.81 62.22,95.08 62.22,97.62 64.77,100.16 64.77,121.12 62.22,123.66 59.68,123.66 59.68,123.02 57.14,120.48 57.14,117.94 58.41,116.67 58.41,112.86 IC14.6
  Bottom 0.254: v71.12,20.16 69.84,21.43 v62.22,21.43
PCA  (via drill 0.61)
  Top 0.254: v213.99,103.97 216.53,101.43 216.53,95.08 220.97,90.64 220.97,15.08 219.71,13.81 211.45,13.81 211.45,13.17 IC37.8
  Bottom 0.254: IC40.5 151.12,12.54 152.4,13.81 208.28,13.81 209.55,12.54 IC37.8 | v213.99,103.97 213.36,103.97 211.45,105.88 IC12.3
PER  (via drill 0.61)
  Top 0.254: v142.24,140.81 140.97,139.53 140.97,134.46 142.24,133.19 IC9.9
  Bottom 0.254: v142.24,140.81 194.31,140.81 209.55,125.56 222.25,125.56 222.25,59.52 219.71,56.98 217.16,56.98 216.53,57.62 212.72,57.62 212.09,58.26 IC30.2
PER\  (via drill 0.61)
  Top 0.254: v176.53,106.52 173.99,109.05 173.99,120.48 171.44,123.02 171.44,128.11 168.91,130.65 168.91,133.19 167,135.09 161.28,135.09 161.28,138.27 156.21,143.34 156.21,143.98 153.66,146.52 143.5,146.52 143.5,134.46 144.78,133.19 IC9.8
  Bottom 0.254: v176.53,106.52 207,106.52 209.55,103.97 IC12.4
PIE  (via drill 0.61)
  Top 0.254: v151.76,5.55 151.76,13.17 150.49,14.44 IC40.4 | v186.69,3.65 190.5,7.46 190.5,8.73 INTENB.2
  Bottom 0.254: v151.76,5.55 153.66,3.65 v186.69,3.65 189.22,3.65 189.86,4.28 221.61,4.28 221.61,50 219.07,52.54 IC30.17
PROTECT
  Bottom 0.254: IC5.6 142.87,136.36 144.14,135.09 160.65,135.09 161.92,136.36 IC6.3
SETNXD\
  Top 0.254: IC23.4 113.66,6.82 112.39,5.55 90.17,5.55 90.17,56.98 91.44,58.26 91.44,93.81 92.7,95.08 92.7,101.43 91.44,102.7 IC21.9
SETPER\  (via drill 0.61)
  Top 0.254: v138.43,128.74 139.69,130.01 139.69,130.65 IC9.10
  Bottom 0.254: v138.43,128.74 137.79,129.38 132.08,129.38 131.44,128.74 127,128.74 125.09,126.83 19.05,126.83 19.05,117.94 20.32,116.67 22.86,116.67 27.3,112.23 IC13.5
SETWLS\
  Top 0.254: IC9.4 137.16,125.56 140.97,129.38 140.97,133.19 138.43,135.72 138.43,140.81 140.97,143.34 140.97,145.89 142.24,147.16 171.44,147.16 171.44,139.53 172.72,138.27 IC6.7
SKIP\  (via drill 0.61)
  Top 0.254: R1.1 183.51,86.19 187.32,86.19 187.32,88.1 IC19.2 | IC19.6 198.12,90 198.12,92.54 195.58,95.08 IC19.10 195.58,97.62 195.58,101.43 v193.03,103.97 | v134.62,105.88 134.62,107.78 132.08,110.32 IC17.2
  Bottom 0.254: v134.62,105.88 135.88,104.61 146.05,104.61 146.68,105.24 175.25,105.24 176.53,103.97 v193.03,103.97 | IC19.2 188.59,88.1 189.86,86.83 196.21,86.83 197.48,88.1 IC19.6
START\  (via drill 0.61)
  Top 0.254: 144.14,44.92 144.14,14.44 142.87,13.17 DMA0-3.11 | 144.14,44.92 142.87,46.19 DMA4-7.11 | 144.14,44.92 144.14,79.21 142.87,80.48 DMA8-11.11 | v157.47,102.07 161.92,106.52 161.92,109.69 162.56,110.32 IC18.3 | v146.05,100.16 v146.05,81.11
  Bottom 0.254: v157.47,102.07 154.94,99.53 146.68,99.53 v146.05,100.16 | v146.05,81.11 143.5,81.11 DMA8-11.11
VCC  (via drill 0.61)
  Top 0.508: C44.1 217.16,90.64 217.8,90 217.8,89.37 FIELD.16 217.8,88.1 215.9,86.19 215.9,65.24 217.16,63.97 C30.1 217.16,62.7 217.8,62.06 217.8,61.43 IC30.20 | IC37.20 217.8,30.95 217.8,31.59 217.16,32.22 C37.1 217.16,33.49 213.99,36.66 v213.99,60.8 | INTENB.16 187.96,18.89 v187.96,40.48 188.59,41.11 188.59,43.02 193.03,47.46 J5.2 193.03,48.73 193.03,50 J4.2 193.03,51.27 193.03,52.54 J3.2 193.03,53.81 189.22,57.62 189.22,91.27 185.41,95.08 IC19.14 | IC12.14 217.8,112.23 217.8,112.86 217.16,113.5 C12.1 216.53,114.13 211.45,119.21 RA.1 210.81,119.85 212.09,121.12 212.09,124.29 IC8.4 211.45,124.93 217.8,131.28 IC8.8 219.71,131.92 219.71,131.28 220.97,130.01 C43X.1 | IC24.20 172.08,99.53 171.44,100.16 171.44,100.8 C24.1 | R1.2 183.51,96.35 184.78,96.35 IC19.14 | IC19.14 185.41,97.62 185.41,98.26 C19.1 185.41,99.53 184.15,100.8 184.15,120.48 | IC11.4 193.03,112.86 195.58,115.4 195.58,117.94 IC11.10 | 184.15,120.48 184.78,119.85 IC11.14 | 184.15,120.48 181.61,123.02 181.61,128.74 180.34,130.01 C7.1 | C31.1 171.44,66.51 172.08,65.88 172.08,65.24 IC31.20 | C39.1 140.33,62.06 139.69,61.43 139.69,60.16 v139.06,59.52 139.69,58.89 139.69,29.68 140.97,28.41 C46.1 | C38.1 171.44,32.22 172.08,31.59 172.08,30.95 IC38.20 171.44,30.32 167,30.32 167,27.14 166.37,26.51 156.21,26.51 156.21,25.87 C40.1 156.21,24.6 156.84,23.96 156.84,23.33 IC40.14 | IC17.16 129.53,120.48 128.27,121.75 128.27,128.74 127,130.01 C9.1 127,131.28 125.73,132.55 125.73,141.44 127,142.71 C5.1 | C8.1 140.97,95.72 141.6,95.08 141.6,94.45 DMA8-11.16 | 156.21,121.75 157.47,120.48 IC18.14
  Top 0.508: 156.21,121.75 156.21,128.74 154.94,130.01 C10.1 | C6.1 154.94,142.71 158.75,138.9 158.75,135.72 157.47,134.46 157.47,133.19 IC10.14 | 156.21,121.75 156.21,96.99 C27.1 156.21,95.72 156.84,95.08 156.84,94.45 DAR8-11.16 156.84,93.18 154.94,91.27 154.94,74.77 156.84,72.86 156.84,63.34 156.21,62.7 C42.1 | IC20.20 17.14,104.61 17.14,105.24 16.51,105.88 C20.1 16.51,107.15 16.51,116.04 15.23,117.31 C13.1 15.23,118.58 11.42,122.39 11.42,141.44 10.15,142.71 C1.1 | C15.1 71.12,117.31 69.84,116.04 69.84,105.88 71.12,104.61 71.12,103.34 C21.1 | C26.1 29.21,75.4 29.84,74.77 29.84,74.13 IC26.20 | IC33.16 45.71,105.24 46.98,106.52 46.98,116.67 45.71,117.94 IC14.14 45.08,119.21 43.81,117.94 C14.1 43.17,118.58 36.82,124.93 36.82,141.44 38.09,142.71 C2.1 | C3.1 65.4,143.34 59.68,149.06 40.63,149.06 40.63,145.89 IC2.16 | RS08.2 40.63,71.59 40,72.22 40,92.54 44.45,96.99 44.45,98.89 43.17,100.16 43.17,102.07 C33.1 | C34.1 29.21,42.38 29.84,41.74 29.84,41.11 IC34.20 31.11,39.84 32.38,38.57 32.38,21.43 35.55,18.25 R2.2 | v38.09,16.98 44.45,10.63 C45.+ | IC4.16 95.88,144.62 94.61,143.34 C4.1 93.98,142.71 92.7,141.44 92.7,122.39 96.52,118.58 C16.1 | 97.79,110.32 99.06,109.05 99.06,103.34 C22.1 | 97.79,110.32 97.79,116.04 99.06,117.31 99.06,117.94 IC16.16 | C28.1 72.39,75.4 73.02,74.77 73.02,74.13 IC28.20 | C35.1 72.39,42.38 73.02,41.74 73.02,41.11 IC35.20 74.29,39.84 75.56,38.57 75.56,15.08 76.2,14.44 C41.1 | IC36.6 109.22,21.43 106.68,18.89 106.68,16.35 IC23.14 | C32.1 93.98,48.73 92.7,47.46 92.7,30.95 93.98,29.68 C36.1 | IC32.16 96.52,51.91 96.52,55.72 97.79,56.98 97.79,59.52 97.15,60.16 97.15,63.97 96.52,64.6 IC29.16 96.52,67.14 96.52,70.95 97.79,72.22 97.79,78.57 96.52,79.84 IC25.16 96.52,82.38 96.52,109.05 97.79,110.32
  Bottom 0.508: v213.99,60.8 217.16,60.8 IC30.20 | C43.1 186.05,16.35 186.69,16.98 187.32,16.98 INTENB.16 | v187.96,40.48 192.4,40.48 J7.2 | RA.1 210.18,119.21 208.91,119.21 RL.1 207.64,119.21 205.74,121.12 193.67,121.12 | R1.2 182.24,96.35 176.53,96.35 173.99,98.89 IC24.20 171.44,98.89 170.18,97.62 161.28,97.62 160.02,96.35 156.84,96.35 C27.1 155.57,96.35 154.3,96.35 153.03,95.08 150.49,95.08 149.86,95.72 142.24,95.72 141.6,96.35 C8.1 | C7.1 180.97,130.65 181.61,131.28 182.24,131.28 IC7.16 | C11.1 183.51,117.94 184.15,118.58 184.78,118.58 IC11.14 186.05,119.85 187.32,121.12 193.67,121.12 | 193.67,121.12 194.94,119.85 IC11.10 | C44.1 217.16,91.91 220.34,95.08 220.34,107.78 217.16,107.78 216.53,108.42 216.53,111.59 217.16,111.59 IC12.14 | C39.1 141.6,62.06 142.24,61.43 149.86,61.43 150.49,60.8 152.4,60.8 153.66,62.06 155.57,62.06 C42.1 156.21,61.43 156.84,61.43 156.84,60.16 DAR4-7.16 158.75,59.52 162.56,63.34 170.18,63.34 171.44,64.6 IC31.20 | v139.06,59.52 140.97,59.52 DMA4-7.16 | C46.1 140.97,27.14 142.24,25.87 DMA0-3.16 143.5,25.23 144.78,26.51 154.3,26.51 155.57,25.23 C40.1 | C5.1 127.63,143.34 128.27,143.98 128.9,143.98 IC5.14 130.17,143.98 131.44,142.71 154.94,142.71 C6.1 155.57,143.34 156.21,143.98 156.84,143.98 IC6.16 | IC17.16 128.9,118.58 128.27,118.58 127.63,117.94 C17.1 126.36,117.94 125.73,117.31 120.65,117.31 120.01,116.67 94.61,116.67 | C9.1 127.63,130.65 128.27,131.28 128.9,131.28 IC9.14 | C18.1 155.57,117.94 156.21,118.58 156.84,118.58 IC18.14 | C10.1 155.57,130.65 156.21,131.28 156.84,131.28 IC10.14 | C1.1 10.79,143.34 11.42,143.98 12.06,143.98 IC1.16
  Bottom 0.508: IC13.3 22.86,112.86 17.78,117.94 IC13.14 17.14,118.58 16.51,118.58 15.87,117.94 C13.1 | C15.1 71.75,117.94 72.39,118.58 73.02,118.58 IC15.14 74.29,118.58 76.83,116.04 93.98,116.04 94.61,116.67 | IC15.3 78.73,110.32 73.66,105.24 IC21.16 73.02,103.34 72.39,103.34 71.75,102.7 C21.1 70.48,102.7 69.84,102.07 43.17,102.07 C33.1 | RS08.2 40,70.95 37.46,73.49 31.75,73.49 IC26.20 | C3.1 66.67,143.34 67.31,143.98 67.94,143.98 IC3.16 | C2.1 38.73,143.34 39.36,143.98 40,143.98 IC2.16 | C33.1 43.81,102.7 44.45,103.34 45.08,103.34 IC33.16 45.71,105.24 50.79,110.32 IC14.3 | IC20.20 19.05,103.97 20.32,102.7 42.54,102.7 C33.1 | R2.2 36.19,17.62 37.46,17.62 v38.09,16.98 41.27,13.81 75.56,13.81 C41.1 76.83,13.81 77.47,14.44 78.1,14.44 IC41.16 79.37,15.71 80.64,16.98 100.33,16.98 103.5,13.81 C23.1 104.77,13.81 105.41,14.44 106.04,14.44 IC23.14 | C22.1 99.69,102.7 100.33,103.34 100.96,103.34 IC22.14 | IC16.16 98.42,118.58 97.79,118.58 97.15,117.94 C16.1 95.88,117.94 94.61,116.67 | C25.1 94.61,79.84 95.25,80.48 95.88,80.48 IC25.16 | IC29.16 95.88,65.24 95.25,65.24 94.61,64.6 C29.1 93.98,65.24 85.72,73.49 74.93,73.49 IC28.20 | C32.1 94.61,49.37 95.25,50 95.88,50 IC32.16 | C36.1 94.61,29.05 95.25,29.68 95.88,29.68 IC36.16 97.15,29.68 102.23,24.6 107.31,24.6 108.58,23.33 IC36.6
WE\  (via drill 0.61)
  Top 0.254: v44.45,91.27 42.54,89.37 42.54,63.97 41.9,63.34 41.27,63.34 RS08.8 | v153.66,139.53 148.59,134.46 v148.59,102.07
  Bottom 0.254: v44.45,91.27 72.39,91.27 72.39,97.62 73.66,98.89 109.22,98.89 111.12,96.99 IC22.5 112.39,96.99 116.2,100.8 141.6,100.8 142.87,102.07 v148.59,102.07 | v153.66,139.53 165.09,139.53 167,137.63 IC6.5
WLS  (via drill 0.61)
  Top 0.254: v138.43,113.5 138.43,121.75 139.69,123.02 IC9.5 | v205.74,105.24 v205.74,25.23
  Bottom 0.254: v138.43,113.5 138.43,109.69 172.08,109.69 176.53,105.24 v205.74,105.24 | v205.74,25.23 208.28,22.7 209.55,22.7 IC37.4
WLS\  (via drill 0.61)
  Top 0.254: v161.28,126.2 163.83,128.74 v163.83,129.38
  Bottom 0.254: v161.28,126.2 160.65,126.83 154.3,126.83 153.66,126.2 144.14,126.2 142.87,124.93 IC9.6 | v163.83,129.38 203.19,129.38 209.55,123.02 211.45,123.02 220.34,114.13 220.34,109.69 219.07,109.69 IC12.13
WRITING  (via drill 0.61)
  Top 0.254: v159.38,128.74 158.75,129.38 158.75,134.46 160.02,135.72 IC6.2 | IC41.13 85.72,14.44 84.45,14.44 IC41.14 83.81,16.35 82.55,17.62 82.55,48.09 v81.91,48.73 81.91,58.89 v82.55,59.52 | v120.65,130.65 115.56,125.56 v115.56,69.68
  Bottom 0.254: v159.38,128.74 160.65,127.47 164.46,127.47 167,124.93 IC10.5 | v81.91,48.73 65.4,48.73 64.13,50 41.9,50 41.27,50.63 RS08.18 | v120.65,130.65 124.45,134.46 163.83,134.46 163.83,138.27 163.19,138.9 161.92,138.9 160.65,137.63 IC6.2 | v115.56,69.68 114.3,68.41 99.06,68.41 97.79,67.14 97.79,60.8 88.26,60.8 86.99,59.52 v82.55,59.52

## Text on the board
Bottom: RF08 | VRS
tPlace: RF08 | VRS